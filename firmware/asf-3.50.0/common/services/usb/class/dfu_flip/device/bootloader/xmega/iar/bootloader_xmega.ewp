# IAR project bootloader_xmega.ewp, settings and files
configuration atxmega128a1u-x2 (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; MIDI_ROUTER_X2
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../clock; ../conf; .; ..; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../boards; ../../../../../../../../../xmega/utils; ../../../../../../udc; ../../../../../..; ../../../../../../../../utils; ../../..; ../../../../../../../isp/flip; ../../../../../../../../../xmega/boards; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../xmega/drivers/cpu; ../../../..; ../../../../../../../../../xmega/boards/dummy
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD; MIDI_ROUTER_X2
  XLINK.XclFile: atxmega128a1u_boot.xcl
configuration atxmega128a1u-x7 (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; MIDI_ROUTER_X7
  AAVR.ADefines: BOARD=DUMMY_BOARD; MIDI_ROUTER_X7
configuration atxmega128a4u-x4 (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.GenDeviceSelectMenu: xm128a4u ATxmega128A4U
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; MIDI_ROUTER_X4
  AAVR.ADefines: BOARD=DUMMY_BOARD; MIDI_ROUTER_X4
  XLINK.XclFile: atxmega128a4u_boot.xcl
configuration atxmega32a4u-x4 (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-xmega-sf-n.h
  General.GenDeviceSelectMenu: xm32a4u ATxmega32A4U
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD; MIDI_ROUTER_X4
  AAVR.ADefines: BOARD=DUMMY_BOARD; MIDI_ROUTER_X4
  XLINK.XclFile: atxmega32a4u_boot.xcl
  group common/boards
    ../../../../../../../../boards/: board.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: osc.h pll.h sysclk.c sysclk.h
  group common/services/isp/flip
    ../../../../../../../isp/flip/: flip_protocol.h isp.h
  group common/services/isp/flip/xmega
    ../../../../../../../isp/flip/xmega/: cstartup.s90 isp.c
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/dfu_flip
    ../../../../: usb_protocol_dfu.h
  group common/services/usb/class/dfu_flip/device
    ../../../: udi_dfu_atmel.c udi_dfu_atmel.h udi_dfu_atmel_conf.h udi_dfu_atmel_desc.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega
    ../: main.c main.h sysclk_opt.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/conf
    ../conf/: conf_board.h conf_clock.h conf_isp.h conf_usb.h
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udc.h udc_desc.h udc_dfu_small.c udd.h udi.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_avr8.h
  group xmega/boards/dummy
    ../../../../../../../../../xmega/boards/dummy/: dummy_board.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.h ccp.s xmega_reset_cause.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm.h nvm_asm.s
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
