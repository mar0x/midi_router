<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootloader_xmega.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>bootloader_xmega</project>
                <configuration>atxmega128a1u-x2</configuration>
            </member>
            <member>
                <project>bootloader_xmega</project>
                <configuration>atxmega128a1u-x7</configuration>
            </member>
            <member>
                <project>bootloader_xmega</project>
                <configuration>atxmega128a4u-x4</configuration>
            </member>
            <member>
                <project>bootloader_xmega</project>
                <configuration>atxmega32a4u-x4</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
